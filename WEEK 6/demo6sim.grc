options:
  parameters:
    generate_options: qt_gui
    id: DEMO6_RX
    output_language: python
    title: Demo 6 RX
  states: {}

blocks:
- name: C0
  id: variable_qtgui_range
  parameters:
    label: Base multiplier for channel 0
    start: '0.5'
    step: '0.5'
    stop: '10'
    value: '1'
  states: {}
- name: C1
  id: variable_qtgui_range
  parameters:
    label: Base multiplier for channel 1
    start: '0.5'
    step: '0.5'
    stop: '10'
    value: '1'
  states: {}
- name: Sim_Setup
  id: variable_qtgui_chooser
  parameters:
    label: Simulation Setup
    label0: Simulation
    label1: Real
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: filt_w
  id: variable_qtgui_range
  parameters:
    label: Filter Width
    start: '2000'
    step: '2000'
    stop: '1000000'
    value: '10000'
  states: {}
- name: rx_X
  id: variable_qtgui_range
  parameters:
    label: receiver position x
    start: '-1.8'
    step: '0.2'
    stop: '1.8'
    value: '0'
  states: {}
- name: rx_Y
  id: variable_qtgui_range
  parameters:
    label: receiver position y
    start: '-1.8'
    step: '0.2'
    stop: '1.8'
    value: '0'
  states: {}
- name: rx_fq
  id: variable_qtgui_range
  parameters:
    label: Receiver center freq
    start: '800000000'
    step: '5000000'
    stop: '1000000000'
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: samp_rate_SDR
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: tx_X0
  id: variable
  parameters:
    value: '-2'
  states: {}
- name: tx_X1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_Y0
  id: variable
  parameters:
    value: '2'
  states: {}
- name: tx_Y1
  id: variable
  parameters:
    value: '-2'
  states: {}
- name: xmlrpc_add
  id: variable
  parameters:
    value: '"localhost"'
  states: {}
- name: zmq_add
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:55555"'
  states: {}
- name: analog_const_source_x_5
  id: analog_const_source_x
  parameters:
    const: '-2'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_0
  id: analog_const_source_x
  parameters:
    const: '-2'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_1
  id: analog_const_source_x
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_2
  id: analog_const_source_x
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_3
  id: analog_const_source_x
  parameters:
    const: rx_X
    type: float
  states: {state: disabled}
- name: analog_const_source_x_5_4
  id: analog_const_source_x
  parameters:
    const: rx_Y
    type: float
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '15000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '5000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filt_w * 2
    low_cutoff_freq: filt_w
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filt_w
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_2
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '3200'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1600'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1600'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: '3200'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_2
  id: blocks_keep_one_in_n
  parameters:
    n: '1600'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: C0/((rx_X - tx_X0)**2   +   (rx_Y - tx_Y0)**2)**0.5
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: C1/((rx_X - tx_X1)**2   +   (rx_Y - tx_Y1)**2)**0.5
    type: complex
  states: {}
- name: blocks_selector_0_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Sim_Setup
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_4
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: Sim_Setup
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport time\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Beacon-Based Prediction',   # will show up in GRC\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n\n    def work(self, input_items, output_items):\n        \"\"\"Finds the highest value\"\"\"\n  \n        in0 = input_items[0]\n        in1 = input_items[1]\n        \n        n = min(len(in0), len(in1), len(output_items[0]))\n\n        for i in range(n):\n                values = [in0[i], in1[i]]\n                output_items[0][i] = np.argmax(values)\n\n        return n\n\n"
  states: {}
- name: note_0
  id: note
  parameters:
    note: Source#1 @ (-2, 2) Source#2 @ (2, -2)
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Real Version
  states: {}
- name: power_calc_1_0
  id: power_calc
  parameters:
    ma_len: '1000'
    samp_rate: samp_rate
  states: {}
- name: power_calc_1_0_0
  id: power_calc
  parameters:
    ma_len: '1000'
    samp_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[3,0,1,1]'
    nconnections: '3'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: '[0,1,2,3]'
    max: '6'
    name: '"Input Values"'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: '[0,0,2,1]'
    max: '2'
    min: '0'
    type: float
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: rx_fq
    samp_rate: samp_rate_SDR
    type: fc32
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: xmlrpc_add
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: zmq_add
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_const_source_x_5, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_5_0, '0', blocks_float_to_complex_1, '0']
- [analog_const_source_x_5_1, '0', blocks_float_to_complex_1, '1']
- [analog_const_source_x_5_2, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_5_3, '0', blocks_float_to_complex_2, '0']
- [analog_const_source_x_5_4, '0', blocks_float_to_complex_2, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_noise_source_x_0_0, '0', blocks_throttle2_0_0_0_1, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_2_0, '0', blocks_multiply_const_vxx_1, '0']
- [band_pass_filter_0, '0', power_calc_1_0, '0']
- [band_pass_filter_1, '0', power_calc_1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_keep_one_in_n_0_0_2, '0']
- [blocks_float_to_complex_1, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_float_to_complex_2, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', qtgui_const_sink_x_0, '2']
- [blocks_keep_one_in_n_0_0_1, '0', epy_block_0_0, '1']
- [blocks_keep_one_in_n_0_0_1, '0', qtgui_number_sink_0_0, '1']
- [blocks_keep_one_in_n_0_0_2, '0', qtgui_const_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_selector_0_2, '0', band_pass_filter_0, '0']
- [blocks_selector_0_4, '0', band_pass_filter_1, '0']
- [blocks_throttle2_0_0_0, '0', blocks_selector_0_2, '0']
- [blocks_throttle2_0_0_0, '0', blocks_selector_0_4, '0']
- [blocks_throttle2_0_0_0_1, '0', blocks_selector_0_2, '1']
- [blocks_throttle2_0_0_0_1, '0', blocks_selector_0_4, '1']
- [epy_block_0_0, '0', qtgui_number_sink_1_0, '0']
- [epy_block_0_0, '0', zeromq_pub_sink_0, '0']
- [power_calc_1_0, '0', blocks_keep_one_in_n_0, '0']
- [power_calc_1_0_0, '0', blocks_keep_one_in_n_0_0_1, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle2_0_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
